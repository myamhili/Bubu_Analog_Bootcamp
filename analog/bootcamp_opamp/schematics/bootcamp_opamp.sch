v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {opamp_two_stage.sym} 0 0 0 0 {name=X1}
C {devices/iopin.sym} -20 -90 0 0 {name=p1 lab=vdpwr}
C {devices/opin.sym} 120 0 0 0 {name=p2 lab=vout}
C {devices/ipin.sym} -150 -50 0 0 {name=p3 lab=vin-}
C {devices/ipin.sym} -150 50 0 0 {name=p4 lab=vin+}
C {devices/ipin.sym} -80 130 0 0 {name=p5 lab=vbn}
C {devices/iopin.sym} -20 90 0 0 {name=p6 lab=vgnd}